IMAGE_INSTALL:append = " camera-gpio camera-handler"
